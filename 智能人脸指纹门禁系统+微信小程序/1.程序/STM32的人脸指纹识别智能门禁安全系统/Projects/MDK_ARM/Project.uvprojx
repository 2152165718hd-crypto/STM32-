# Keil uVision project Project.uvprojx, settings and files
target Temolate (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xb.s
  group User
    ../../Users/: stm32f1xx_it.c main.h main.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c delay.h
    ../../Drivers/SYSTEM/sys/: sys.c sys.h
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c
  group Drivers/Hardware
    ../../Drivers/Hardware/KEY/: KEY.c KEY.h
    ../../Drivers/Hardware/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../../Drivers/Hardware/FM225/: FM225.c FM225.h
    ../../Drivers/Hardware/RC522/: RC522.c RC522.h
    ../../Drivers/Hardware/LED/: LED.c LED.h
    ../../Drivers/Hardware/Buzzer/: Buzzer.c Buzzer.h
    ../../Drivers/Hardware/Servo/: Servo.c Servo.h
    ../../Drivers/Hardware/AS608/: AS608.c AS608.h
    ../../Drivers/Hardware/ESP_01S/: ESP_01S.c ESP_01S.h
  group Application
    ../../Drivers/APPLICATION/Menu/: Menu.c Menu.h MenuFramework.c MenuFramework.h
  group Middlewares
    ../../Middlewares/OneNet_MQTT/: cJSON.c cJSON.h Common.h MqttKit.c MqttKit.h onenet.c onenet.h
