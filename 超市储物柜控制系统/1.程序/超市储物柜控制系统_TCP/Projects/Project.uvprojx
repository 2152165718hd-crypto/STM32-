# Keil uVision project Project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers;..\Users
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../Users/: main.c locker_app.c locker_app.h app_ui_font.c app_ui_font.h stm32f4xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/System
    ../Drivers/SYSTEM/sys/: sys.c sys.h
    ../Drivers/SYSTEM/usart/: usart.c usart.h
    ../Drivers/SYSTEM/delay/: delay.c delay.h
  group Drivers/_HAL_Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/HARDWARE
    ../Drivers/HARDWARE/AT24C256/: AT24C256.c AT24C256.h
    ../Drivers/HARDWARE/Buzzer/: Buzzer.c Buzzer.h
    ../Drivers/HARDWARE/ESP_01S/: ESP_01S.c ESP_01S.h
    ../Drivers/HARDWARE/FM225/: FM225.c FM225.h
    ../Drivers/HARDWARE/Independent_Key/: KEY.c KEY.h
    ../Drivers/HARDWARE/Matrix_Keypad/: Matrix_Keypad.c Matrix_Keypad.h
    ../Drivers/HARDWARE/PCF8563/: PCF8563.c PCF8563.h
    ../Drivers/HARDWARE/Relay/: Relay.c Relay.h
    ../Drivers/HARDWARE/TFT_ST7735/: TFT_Data.c TFT_Data.h TFT_ST7735.c TFT_ST7735.h
