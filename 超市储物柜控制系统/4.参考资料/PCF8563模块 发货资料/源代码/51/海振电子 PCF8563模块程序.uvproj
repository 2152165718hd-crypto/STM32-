# Keil uVision project 海振电子 PCF8563模块程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 海振电子 PCF8563模块程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 海振电子 PCF8563模块程序.c uart.c PCF8563.c
