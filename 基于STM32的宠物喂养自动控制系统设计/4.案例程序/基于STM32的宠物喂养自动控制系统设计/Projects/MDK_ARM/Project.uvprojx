# Keil uVision project Project.uvprojx, settings and files
target Temolate (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no-multibyte-chars
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Middlewares\OneNet_MQTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xb.s
  group User
    ../../Users/: stm32f1xx_it.c main.h main.c stm32f1xx_hal_conf.h
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c delay.h
    ../../Drivers/SYSTEM/sys/: sys.c sys.h
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c
  group Drivers/Hardware
    ../../Drivers/Hardware/OLED/: OLED_Data.c OLED_Data.h OLED.c OLED.h
    ../../Drivers/Hardware/KEY/: KEY.c KEY.h
    ../../Drivers/Hardware/Actuators/: Actuators.c Actuators.h
    ../../Drivers/Hardware/ADC_Sensors/: ADC_Sensors.c ADC_Sensors.h
    ../../Drivers/Hardware/Buzzer/: Buzzer.c Buzzer.h
    ../../Drivers/Hardware/DHT11/: DHT11.c DHT11.h
    ../../Drivers/Hardware/HC_SR04/: HC_SR04.c HC_SR04.h
    ../../Drivers/Hardware/HX711_WeighingModule/: HX711_WeighingModule.c HX711_WeighingModule.h
    ../../Drivers/Hardware/JQ8400/: JQ8400.c JQ8400.h
    ../../Drivers/Hardware/Servo/: Servo.c Servo.h
    ../../Drivers/Hardware/AirM2M_4G/: AirM2M_4G.c AirM2M_4G.h
  group Application
    ../../Drivers/APPLICATION/Menu/: MenuFramework.c MenuFramework.h
    ../../Drivers/APPLICATION/PetFeeder/: PetFeeder.c PetFeeder.h
  group Middlewares/OneNet_MQTT
    ../../Middlewares/OneNet_MQTT/: Common.h MqttKit.c MqttKit.h onenet.c onenet.h onenet_config.h
